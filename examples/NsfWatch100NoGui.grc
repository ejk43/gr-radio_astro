options:
  parameters:
    author: Glen Langston
    description: AIRSPY Dongle at full speed 10 MHz samples
    generate_options: no_gui
    id: NsfWatch100NoGui
    output_language: python
    title: NSF Airspy 10 MHz - No Gui
  states: {}

blocks:
- name: Azimuth
  id: variable
  parameters:
    value: Azimuth_save
  states: {}
- name: Azimuth_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: azimuth
    section: main
    type: real
    value: '90.'
    writeback: Azimuth
  states: {}
- name: Bandwidth
  id: variable
  parameters:
    value: Bandwidths
  states: {}
- name: Bandwidths
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Bandwidth
    section: main
    type: real
    value: 10.e6
    writeback: Bandwidth
  states: {}
- name: ConfigFile
  id: variable
  parameters:
    value: ObsName+".conf"
  states: {}
- name: Device
  id: variable
  parameters:
    value: device_save
  states: {}
- name: Elevation
  id: variable
  parameters:
    value: Elevation_save
  states: {}
- name: Elevation_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: elevation
    section: main
    type: real
    value: '90.'
    writeback: Elevation
  states: {}
- name: EventMode
  id: variable
  parameters:
    value: '1'
  states: {}
- name: Frequency
  id: variable
  parameters:
    value: Frequencys
  states: {}
- name: Frequencys
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Frequency
    section: main
    type: real
    value: 1420.4e6
    writeback: Frequency
  states: {}
- name: Gain1
  id: variable
  parameters:
    value: Gain1s
  states: {}
- name: Gain1s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain1
    section: main
    type: real
    value: '14.'
    writeback: Gain1
  states: {}
- name: Gain2
  id: variable
  parameters:
    value: Gain2s
  states: {}
- name: Gain2s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain2
    section: main
    type: real
    value: '12'
    writeback: Gain2
  states: {}
- name: Gain3
  id: variable
  parameters:
    value: Gain3s
  states: {}
- name: Gain3s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain3
    section: main
    type: real
    value: '13'
    writeback: Gain3
  states: {}
- name: ObsName
  id: variable
  parameters:
    value: '"Integrate100"'
  states: {}
- name: Record
  id: variable
  parameters:
    value: '1'
  states: {}
- name: Telescope
  id: variable
  parameters:
    value: telescope_save
  states: {}
- name: device_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: device
    section: main
    type: string
    value: airspy,bias=1,pack=1
    writeback: Device
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: fftsize_save
  states: {}
- name: fftsize_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: fftsize
    section: main
    type: int
    value: '1024'
    writeback: fftsize
  states: {}
- name: nAve
  id: variable
  parameters:
    value: nAves
  states: {}
- name: nAves
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nave
    section: main
    type: int
    value: '20'
    writeback: nAve
  states: {}
- name: nsigma
  id: variable
  parameters:
    value: nsigmas
  states: {}
- name: nsigmas
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nsigma
    section: main
    type: real
    value: '5.5'
    writeback: nsigma
  states: {}
- name: observer
  id: variable
  parameters:
    value: observers_save
  states: {}
- name: observers_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: observers
    section: main
    type: string
    value: Science Aficionado
    writeback: observer
  states: {}
- name: telescope_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: telescope
    section: main
    type: string
    value: Bubble Wrap Horn
    writeback: Telescope
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 2*fftsize
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.hamming(fftsize)
  states: {}
- name: note_1
  id: note
  parameters:
    note: The sequence of vector medians removes temporary RFI
  states: {}
- name: radio_astro_detect_0
  id: radio_astro_detect
  parameters:
    bw: Bandwidth
    dms: nsigma
    f_obs: Frequency
    mode: '2'
    t_int: fftsize*1.e-6/Bandwidth
    vec_length: 2*fftsize
  states: {}
- name: radio_astro_ra_ascii_sink_0
  id: radio_astro_ra_ascii_sink
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidth
    device: device_save
    elevation: Elevation
    frequency: Frequency
    gain1: float(Gain1)
    gain2: float(Gain2)
    gain3: float(Gain3)
    nave: nAve
    nmedian: 4**5
    observers: observer
    obstype: '0'
    record: Record
    setup: ObsName+".not"
    site: telescope_save
    vlen: fftsize
  states: {}
- name: radio_astro_ra_event_log_0
  id: radio_astro_ra_event_log
  parameters:
    logname: ''
    note: Event Detection
    sample_rate: Bandwidth*1.e-6
    vlen: 2*fftsize
  states: {}
- name: radio_astro_ra_event_sink_0
  id: radio_astro_ra_event_sink
  parameters:
    azimuth: Azimuth
    device: Device
    elevation: Elevation
    frequency: Frequency*1.E-6
    gain1: float(Gain1)
    note: Event Detection
    observers: Science Aficionados
    record: EventMode
    sample_rate: Bandwidth*1.E-6
    setup: ObsName+"Event.not"
    telescope: Telescope
    vlen: 2*fftsize
  states: {}
- name: radio_astro_vmedian_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: '1024'
  states: {}
- name: radio_astro_vmedian_0_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: '1024'
  states: {}
- name: radio_astro_vmedian_0_0_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: '1024'
  states: {}
- name: radio_astro_vmedian_0_0_1
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: '1024'
  states: {}
- name: radio_astro_vmedian_0_0_1_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: '1024'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    affinity: '3'
    args: Device
    bb_gain0: float(Gain2)
    bw0: Bandwidth
    freq0: Frequency
    gain0: float(Gain1)
    gain_mode0: 'False'
    if_gain0: float(Gain2)
    sample_rate: Bandwidth
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', radio_astro_vmedian_0_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', radio_astro_detect_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_log_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_sink_0, '0']
- [radio_astro_ra_ascii_sink_0, '0', blocks_null_sink_0, '0']
- [radio_astro_vmedian_0, '0', radio_astro_ra_ascii_sink_0, '0']
- [radio_astro_vmedian_0_0, '0', radio_astro_vmedian_0, '0']
- [radio_astro_vmedian_0_0_0, '0', radio_astro_vmedian_0_0, '0']
- [radio_astro_vmedian_0_0_1, '0', radio_astro_vmedian_0_0_1_0, '0']
- [radio_astro_vmedian_0_0_1_0, '0', radio_astro_vmedian_0_0_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0_0_0, '0']

metadata:
  file_format: 1
