options:
  parameters:
    author: Glen Langston
    description: Event Detection using Airspy
    generate_options: qt_gui
    id: NsfDetect60
    output_language: python
    title: 'Nsf Airspy Mini Event Detect: 6 MHz'
  states: {}

blocks:
- name: Azimuth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,6,1,2
    label: Azimuth
    type: real
    value: Azimuth_save
  states: {}
- name: Azimuth_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: azimuth
    section: main
    type: real
    value: '180.'
    writeback: Azimuth
  states: {}
- name: Bandwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,4,1,2
    label: Bandwidth
    type: real
    value: Bandwidths
  states: {}
- name: Bandwidths
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: bandwidth
    section: main
    type: real
    value: 6e6
    writeback: Bandwidth
  states: {}
- name: ConfigFile
  id: variable
  parameters:
    value: ObsName+".conf"
  states: {}
- name: Device
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,2
    label: Dev
    type: string
    value: device_save
  states: {}
- name: Elevation
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,6,1,2
    label: Elevation
    type: real
    value: Elevation_save
  states: {}
- name: Elevation_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: elevation
    section: main
    type: real
    value: '90.'
    writeback: Elevation
  states: {}
- name: EventMode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,0, 1, 2
    label: Write Mode
    label0: Wait
    label1: Write
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: Frequency
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,4,1,2
    label: Freq. Hz
    type: real
    value: Frequencys
  states: {}
- name: Frequencys
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: frequency
    section: main
    type: real
    value: 1420.4e6
    writeback: Frequency
  states: {}
- name: Gain1
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,2,1,2
    label: Gain1
    type: real
    value: Gain1s
  states: {}
- name: Gain1s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain1
    section: main
    type: real
    value: '14'
    writeback: Gain1
  states: {}
- name: Gain2
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,4,1,2
    label: Gain2
    type: real
    value: Gain2s
  states: {}
- name: Gain2s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain2
    section: main
    type: real
    value: '14.'
    writeback: Gain2
  states: {}
- name: Gain3
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,6,1,2
    label: Gain3
    type: real
    value: Gain3s
  states: {}
- name: Gain3s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain3
    section: main
    type: real
    value: '14.'
    writeback: Gain3
  states: {}
- name: Mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6,0,1,2
    label: Data Mode
    label0: Monitor
    label1: Detect
    num_opts: '2'
    option0: '0'
    option1: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '2'
    widget: radio_buttons
  states: {}
- name: ObsName
  id: variable
  parameters:
    value: '"Detect60"'
  states: {}
- name: Observer
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,2
    label: Who
    type: string
    value: observer_save
  states: {}
- name: Telescope
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,2
    label: Tel
    type: string
    value: telescope_save
  states: {}
- name: device_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: device
    section: main
    type: string
    value: airspy,bias=1,pack=1
    writeback: Device
  states: {}
- name: fftsize
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,2,1,2
    label: Sample_Size
    type: int
    value: fftsize_save
  states: {}
- name: fftsize_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: samplesize
    section: main
    type: int
    value: '1024'
    writeback: fftsize
  states: {}
- name: nsigma
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,2
    label: N Sigma
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.'
    step: '.1'
    stop: '10.'
    value: nsigmas
    widget: counter
  states: {}
- name: nsigmas
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nsimga
    section: main
    type: real
    value: '5.5'
    writeback: nsigma
  states: {}
- name: observer_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: observer
    section: main
    type: string
    value: Science Aficionado
    writeback: Observer
  states: {}
- name: telescope_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: telescope
    section: main
    type: string
    value: My Horn
    writeback: Telescope
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: Device
    bb_gain0: float(Gain3)
    bw0: Bandwidth
    freq0: Frequency
    gain0: float(Gain1)
    gain_mode0: 'False'
    if_gain0: float(Gain2)
    sample_rate: Bandwidth
    sync: sync
    type: fc32
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: 3,0,2,2
    label1: I
    label2: Q
    nconnections: '2'
    size: fftsize
    type: float
    update_time: '1'
    xmax: '.5'
    xmin: '-.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,2,5,6
    label1: I
    label2: Q
    size: fftsize
    srate: Bandwidth
    type: complex
    update_time: '1'
    ylabel: Event
    ymax: '.3'
    ymin: '-.3'
  states: {}
- name: radio_astro_detect_0
  id: radio_astro_detect
  parameters:
    bw: Bandwidth
    dms: nsigma
    f_obs: Frequency
    mode: Mode
    t_int: fftsize*1.e-6/Bandwidth
    vec_length: fftsize
  states: {}
- name: radio_astro_ra_event_log_0
  id: radio_astro_ra_event_log
  parameters:
    logname: ''
    note: Event Detection
    sample_rate: Bandwidth*1.e-6
    vlen: fftsize
  states: {}
- name: radio_astro_ra_event_sink_0
  id: radio_astro_ra_event_sink
  parameters:
    azimuth: Azimuth
    device: Device
    elevation: Elevation
    frequency: Frequency*1.E-6
    gain1: float(Gain1)
    note: Event Detection
    observers: Science Aficionados
    record: EventMode
    sample_rate: Bandwidth*1.E-6
    setup: ObsName+".not"
    telescope: Telescope
    vlen: fftsize
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_histogram_sink_x_0, '1']
- [blocks_stream_to_vector_0, '0', radio_astro_detect_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_float_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [radio_astro_detect_0, '0', blocks_vector_to_stream_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_log_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_sink_0, '0']

metadata:
  file_format: 1
