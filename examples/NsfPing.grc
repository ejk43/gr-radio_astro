options:
  parameters:
    author: Glen Langston
    description: Diagnostic test design
    generate_options: qt_gui
    id: NsfPing
    output_language: python
    realtime_scheduling: '1'
    title: Test Signal.  Adds a Short pulse in a narrow Band
  states: {}

blocks:
- name: Attn1
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,2
    label: Attn1
    type: real
    value: '80'
  states: {}
- name: Bandwidth
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: EventMode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,0, 1, 2
    label: Write Mode
    label0: Wait
    label1: Write
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: FreqMHz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,2
    label: Freq (MHz)
    type: real
    value: '1398'
  states: {}
- name: Frequency
  id: variable
  parameters:
    value: FreqMHz*1.E6
  states: {}
- name: Gain1
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,2
    label: Gain1
    type: real
    value: '40'
  states: {}
- name: H1
  id: variable
  parameters:
    value: 1420.406E6
  states: {}
- name: Mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6,0,1,2
    label: Data Mode
    label0: Monitor
    label1: Detect
    num_opts: '2'
    option0: '0'
    option1: '2'
    type: int
    value: '2'
  states: {}
- name: Offset
  id: variable
  parameters:
    value: OffsetMHz*1.E6
  states: {}
- name: OffsetMHz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,2,1,2
    label: OffsetMHz)
    type: real
    value: '0.111'
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: nsigma
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,1
    label: N Sigma
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.'
    step: '.1'
    stop: '10.'
    value: '4.5'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: Ping
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,4,2,5
    label1: Ping
    min: '0.'
    name: '"Ramp"'
    type: float
    update_time: '0.5'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.15'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.00001'
    freq: '.0002'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1.'
    init: '1.'
    low: '.999999'
    maxoutbuf: '1'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: pluto_sink_0
  id: pluto_sink
  parameters:
    attenuation: float(Attn1)
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '0x8000'
    cyclic: 'False'
    filter: ''
    frequency: float(Frequency+Offset)
    samplerate: float(Bandwidth)
    uri: ''
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: 2,0,3,2
    label1: I
    label2: Q
    nconnections: '2'
    size: fftsize
    type: float
    update_time: '1.'
    xmax: '.4'
    xmin: '-.4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,3,5,6
    label1: I
    label2: Q
    size: fftsize
    srate: Bandwidth
    type: complex
    update_time: '1'
    ylabel: Event
    ymax: '.3'
    ymin: '-.3'
  states: {}
- name: radio_astro_detect_0
  id: radio_astro_detect
  parameters:
    bw: Bandwidth
    dms: nsigma
    f_obs: Frequency
    mode: Mode
    t_int: fftsize*1.e-6/Bandwidth
    vec_length: fftsize
  states: {}
- name: radio_astro_ra_event_log_0
  id: radio_astro_ra_event_log
  parameters:
    logname: ''
    note: Event Detection
    sample_rate: Bandwidth
    vlen: fftsize
  states: {}
- name: radio_astro_ra_event_sink_0
  id: radio_astro_ra_event_sink
  parameters:
    azimuth: '0.'
    device: ''
    elevation: '90.'
    frequency: Frequency*1.E-6
    gain1: Gain1
    note: Event Detection
    observers: Science Aficionados
    record: EventMode
    sample_rate: Bandwidth
    setup: Detect40.not
    telescope: My Horn
    vlen: fftsize
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', Ping, '0']
- [analog_sig_source_x_0, '0', blocks_threshold_ff_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_histogram_sink_x_0, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_stream_to_vector_0, '0', radio_astro_detect_0, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0_0, '0']
- [radio_astro_detect_0, '0', blocks_vector_to_stream_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_log_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_sink_0, '0']

metadata:
  file_format: 1
